# Keil uVision project mrt.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mrt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\stlib\inc;..\mlib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20002000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group mlib
    ../mlib/: main.c m_thread.c m_thread_switch.S
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.3
